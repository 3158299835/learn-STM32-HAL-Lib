# Keil uVision project Project.uvprojx, settings and files
target Project (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F103xB
  c include: .\CMSIS\Include;.\Library\Include;.\Hardware\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/Source/: system_stm32f1xx.c startup_stm32f101xb.s
  group Library
    ./Library/Source/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c
  group Hardware
    ./Hardware/Source/: rcc.c led.c stm32f1xx_it.c key.c
  group User
    ./User/: main.c
